require optee-test.inc

SRCREV = "ab9863cc187724e54c032b738c28bd6e9460a4db"
